FILESEXTRAPATHS:prepend:static_eth0 := "${THISDIR}/${PN}:"