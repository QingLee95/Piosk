FILESEXTRAPATH:prepend := "${THISDIR}/${PN}"