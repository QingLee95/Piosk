include recipes-core/images/rpi-test-image.bb

SUMMARY = "Image for the Raspberry Pi Zero 2W"